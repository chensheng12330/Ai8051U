# Keil uVision project Dis_TEST.uvproj, settings and files
target Target 1 (MCS-251)
  device: AI8051U-32Bit Series AI
  cpu: IRAM(0-0x7FF) XRAM(0x10000-0x17FFF) IROM(0xFF0000-0xFFFFFF) CLOCK(35000000)
  output: Dis_TEST +hex
  BeforeMake: .\Auto_Keil.exe
  asm include: .vscode;Hex File;Listings
  link misc: REMOVEUNUSED
  group Source Group 1
    ./: main.c set_io.c set_spi.c set_task.c set_timer.c stc_usb_cdc_32g.LIB
