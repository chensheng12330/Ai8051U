# Keil uVision project TIMER_Test.uvproj, settings and files
target Target 1 (MCS-251)
  device: AI8051U-32Bit Series AI
  cpu: IRAM(0-0x7FF) XRAM(0x10000-0x17FFF) IROM(0xFF0000-0xFFFFFF) CLOCK(35000000)
  output: TIMER_Test +hex
  link misc: REMOVEUNUSED
  group Source Group 1
    ./: main.c set_io.c set_int.c set_int.h set_timer.c set_timer.h AI8051U_32_MDU32.LIB AI8051U_32_TFPU.LIB
