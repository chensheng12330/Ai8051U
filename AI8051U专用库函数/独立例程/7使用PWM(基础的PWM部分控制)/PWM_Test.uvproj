# Keil uVision project PWM_Test.uvproj, settings and files
target Target 1 (MCS-251)
  device: AI8051U-32Bit Series AI
  cpu: IRAM(0-0x7FF) XRAM(0x10000-0x17FFF) IROM(0xFF0000-0xFFFFFF) CLOCK(35000000)
  output: PWM_Test +hex
  link misc: REMOVEUNUSED
  group Source Group 1
    ./: main.c set_pwm.c set_pwm.h set_io.c
