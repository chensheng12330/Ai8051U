# Keil uVision project AI8051U-LIB.uvproj, settings and files
target Target 1 (MCS-251)
  device: AI8051U-32Bit Series AI
  cpu: IRAM(0-0x7FF) XRAM(0x10000-0x17FFF) IROM(0xFF0000-0xFFFFFF) CLOCK(35000000)
  output: AI8051U-LIB +hex
  link misc: REMOVEUNUSED
  group User
    ../User/: main.c system_init.c Task.c isr.asm
  group APP
    ../App/src/: APP.c APP_AD_UART.c APP_Lamp.c APP_INT_UART.c APP_RTC.c APP_I2C.c APP_SPI_Flash.c APP_WDT.c APP_EEPROM.c APP_PWMA_Output.c APP_PWMB_Output.c APP_DMA_AD.c APP_DMA_LCM.c APP_DMA_M2M.c APP_DMA_SPI_Flash.c APP_DMA_UART.c APP_DMA_I2C.c APP_USART_LIN.c APP_USART2_LIN.c APP_HSSPI.c APP_HSPWM.c APP_USB.c APP_QSPI_Flash.c APP_GPIO_INT.c
  group Driver
    ../Driver/src/: AI8051U_ADC.c AI8051U_Clock.c AI8051U_Compare.c AI8051U_Delay.c AI8051U_DMA.c AI8051U_EEPROM.c AI8051U_Exti.c AI8051U_GPIO.c AI8051U_I2C.c AI8051U_LCM.c AI8051U_NVIC.c AI8051U_PWM.c AI8051U_RTC.c AI8051U_Soft_I2C.c AI8051U_Soft_UART.c AI8051U_SPI.c AI8051U_Timer.c AI8051U_UART.c AI8051U_USART_LIN.c AI8051U_WDT.c AI8051U_QSPI.c
  group ISR
    ../Driver/isr/: AI8051U_ADC_Isr.c AI8051U_Compare_Isr.c AI8051U_DMA_Isr.c AI8051U_Exti_Isr.c AI8051U_GPIO_Isr.c AI8051U_I2C_Isr.c AI8051U_LCM_Isr.c AI8051U_PWM_Isr.c AI8051U_RTC_Isr.c AI8051U_SPI_Isr.c AI8051U_Timer_Isr.c AI8051U_UART_Isr.c AI8051U_QSPI_Isr.c
  group LIB
    ../Driver/lib/: AI8051U_32_MDU32.LIB AI8051U_32_TFPU.LIB stc_usb_cdc_32g.LIB
