# Keil uVision project LIN.uvproj, settings and files
target Target 1 (MCS-251)
  device: AI8051U-32Bit Series AI
  cpu: IRAM(0-0x7FF) XRAM(0x10000-0x17FFF) IROM(0xFF0000-0xFFFFFF) CLOCK(35000000)
  output: LIN +hex
  link misc: REMOVEUNUSED
  group Source Group 1
    ./: main.c AI8051U_Delay.c AI8051U_GPIO.c AI8051U_NVIC.c AI8051U_UART.c AI8051U_UART_Isr.c AI8051U_USART_LIN.c stc_usb_cdc_32g.LIB
