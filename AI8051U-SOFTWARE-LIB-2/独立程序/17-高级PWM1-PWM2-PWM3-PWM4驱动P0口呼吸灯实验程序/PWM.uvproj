# Keil uVision project PWM.uvproj, settings and files
target Target 1 (MCS-251)
  device: AI8051U-32Bit Series AI
  cpu: IRAM(0-0x7FF) XRAM(0x10000-0x17FFF) IROM(0xFF0000-0xFFFFFF) CLOCK(35000000)
  output: PWM +hex
  link misc: REMOVEUNUSED
  group Source Group 1
    ./: main.c AI8051U_GPIO.c AI8051U_NVIC.c AI8051U_PWM.c AI8051U_PWM_Isr.c AI8051U_Timer.c AI8051U_Timer_Isr.c
