# Keil uVision project compare.uvproj, settings and files
target Target 1 (MCS-251)
  device: AI8051U-32Bit Series AI
  cpu: IRAM(0-0x7FF) XRAM(0x10000-0x17FFF) IROM(0xFF0000-0xFFFFFF) CLOCK(35000000)
  output: compare +hex
  link misc: REMOVEUNUSED
  group Source Group 1
    ./: main.c AI8051U_Compare.c AI8051U_Compare_Isr.c AI8051U_GPIO.c AI8051U_NVIC.c
