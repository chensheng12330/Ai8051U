# Keil uVision project Test.uvproj, settings and files
target Test (MCS-251)
  device: STC8051U-32Bit Series STC
  cpu: IRAM(0-0x7FF) XRAM(0x10000-0x17FFF) IROM(0xFF0000-0xFFFFFF) CLOCK(35000000)
  output: Test +hex
  link misc: //REMOVEUNUSED
  group Source
    ./: TLV320AIC23.c main.c uart.c W25Q128FV.c
  group USB
    ./usb/: usb.c usb_desc.c usb_req_class.c usb_req_std.c usb_req_vendor.c util.c
