# Keil uVision project UART2.uvproj, settings and files
target USART2 (MCS-251)
  device: STC8051U-32Bit Series STC
  cpu: IRAM(0-0x7FF) XRAM(0x10000-0x17FFF) IROM(0xFF0000-0xFFFFFF) CLOCK(35000000)
  output: UART2 +hex
  group Source
    ./: UART2.c isr.asm 功能说明.txt
