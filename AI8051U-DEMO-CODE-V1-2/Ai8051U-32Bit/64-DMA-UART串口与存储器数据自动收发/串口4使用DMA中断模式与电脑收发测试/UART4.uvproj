# Keil uVision project UART4.uvproj, settings and files
target UART4 (MCS-251)
  device: STC8051U-32Bit Series STC
  cpu: IRAM(0-0x7FF) XRAM(0x10000-0x17FFF) IROM(0xFF0000-0xFFFFFF) CLOCK(35000000)
  output: UART4 +hex
  group Source
    ./: UART4.c isr.asm 功能说明.txt
