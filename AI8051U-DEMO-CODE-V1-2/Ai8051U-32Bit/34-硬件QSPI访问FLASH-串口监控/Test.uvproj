# Keil uVision project Test.uvproj, settings and files
target Target 1 (MCS-251)
  device: STC8051U-32Bit Series STC
  cpu: IRAM(0-0x7FF) XRAM(0x10000-0x17FFF) IROM(0xFF0000-0xFFFFFF) CLOCK(35000000)
  output: Test +hex
  link misc: REMOVEUNUSED
  group Source Group 1
    ./: Test.c qspi.c w25qxx.c
