# Keil uVision project I2C.uvproj, settings and files
target I2C (MCS-251)
  device: STC8051U-32Bit Series STC
  cpu: IRAM(0-0x7FF) XRAM(0x10000-0x17FFF) IROM(0xFF0000-0xFFFFFF) CLOCK(35000000)
  output: I2C +hex
  group Source
    ./: I2C.c ISR.asm 功能说明.txt
