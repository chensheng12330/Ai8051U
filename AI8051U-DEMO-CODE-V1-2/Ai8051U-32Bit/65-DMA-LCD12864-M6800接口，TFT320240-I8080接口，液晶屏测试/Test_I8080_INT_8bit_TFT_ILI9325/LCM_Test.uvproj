# Keil uVision project LCM_Test.uvproj, settings and files
target LCM_Test (MCS-251)
  device: STC8051U-32Bit Series STC
  cpu: IRAM(0-0x7FF) XRAM(0x10000-0x17FFF) IROM(0xFF0000-0xFFFFFF) CLOCK(35000000)
  output: LCM_Test +hex
  group Source
    ./: LCM_Test.c ISR.asm
