# Keil uVision project wake_up.uvproj, settings and files
target wake_up (MCS-251)
  device: AI8051U-32Bit Series AI
  cpu: IRAM(0-0x7FF) XRAM(0x10000-0x17FFF) IROM(0xFF0000-0xFFFFFF) CLOCK(35000000)
  output: wake_up +hex
  group Source
    ./: wake_up.asm 功能说明.txt
