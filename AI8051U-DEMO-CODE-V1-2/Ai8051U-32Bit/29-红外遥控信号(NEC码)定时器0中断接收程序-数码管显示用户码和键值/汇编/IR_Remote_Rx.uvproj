# Keil uVision project IR_Remote_Rx.uvproj, settings and files
target IR_Remote_Rx (MCS-251)
  device: STC8051U-32Bit Series STC
  cpu: IRAM(0-0x7FF) XRAM(0x10000-0x17FFF) IROM(0xFF0000-0xFFFFFF) CLOCK(35000000)
  output: IR_Remote_Rx +hex
  group Source
    ./: IR_Remote_Rx.asm 功能说明.txt
