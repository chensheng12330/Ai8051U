# Keil uVision project usb_cdc.uvproj, settings and files
target Target 1 (MCS-251)
  device: STC8051U-32Bit Series STC
  cpu: IRAM(0-0x7FF) XRAM(0x10000-0x17FFF) IROM(0xFF0000-0xFFFFFF) CLOCK(35000000)
  output: usb_ser +hex
  group Source Group 1
    ./src/: main.c
    ../COMM/: usb_cdc_32.LIB
