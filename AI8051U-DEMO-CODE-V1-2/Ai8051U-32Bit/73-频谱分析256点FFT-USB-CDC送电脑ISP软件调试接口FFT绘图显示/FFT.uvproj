# Keil uVision project FFT.uvproj, settings and files
target FFT (MCS-251)
  device: STC8051U-32Bit Series STC
  cpu: IRAM(0-0x7FF) XRAM(0x10000-0x17FFF) IROM(0xFF0000-0xFFFFFF) CLOCK(35000000)
  output: FFT +hex
  link misc: REMOVEUNUSED
  group source
    ./src/: uart.c STC32_MDU32_LARGE_V1.1.LIB STC32_FPMU_LARGE_V1.0.LIB FFT-V11-256dots-CDC-PWMA触发ADC.c
  group USB
    ./src/usb/: usb.c usb_desc.c usb_req_class.c usb_req_std.c usb_req_vendor.c util.c
