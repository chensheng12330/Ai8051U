# Keil uVision project LCD1602.uvproj, settings and files
target Target 1 (MCS-251)
  device: STC32F12K64 Series STC
  cpu: IRAM(0-0x1FFF) XRAM(0x10000-0x10FFF) IROM(0xFF0000-0xFFFFFF) CLOCK(35000000)
  output: LCD1602 +hex
  group Source Group 1
    ./: LCD1602-LCM-DMA.c
