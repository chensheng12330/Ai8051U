# Keil uVision project UART.uvproj, settings and files
target UART (MCS-251)
  device: STC8051U-32Bit Series STC
  cpu: IRAM(0-0x7FF) XRAM(0x10000-0x17FFF) IROM(0xFF0000-0xFFFFFF) CLOCK(35000000)
  output: UART +hex
  group Source
    ./: UART.c 功能说明.txt
