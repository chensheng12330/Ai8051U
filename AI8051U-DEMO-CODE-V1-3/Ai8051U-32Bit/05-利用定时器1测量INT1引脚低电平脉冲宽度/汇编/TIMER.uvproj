# Keil uVision project TIMER.uvproj, settings and files
target timer (MCS-251)
  device: STC8051U-32Bit Series STC
  cpu: IRAM(0-0x7FF) XRAM(0x10000-0x17FFF) IROM(0xFF0000-0xFFFFFF) CLOCK(35000000)
  output: TIMER +hex
  group Source
    ./: TIMER.asm 功能说明.txt
