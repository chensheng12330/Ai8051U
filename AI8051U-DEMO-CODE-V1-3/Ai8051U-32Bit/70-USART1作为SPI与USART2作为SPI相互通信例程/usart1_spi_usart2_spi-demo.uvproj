# Keil uVision project usart1_spi_usart2_spi-demo.uvproj, settings and files
target demo (MCS-251)
  device: STC8051U-32Bit Series STC
  cpu: IRAM(0-0x7FF) XRAM(0x10000-0x17FFF) IROM(0xFF0000-0xFFFFFF) CLOCK(35000000)
  output: usart1_spi_usart2_spi-demo +hex
  link misc: REMOVEUNUSED
  group main
    ./src/: main.c
    ./: 功能说明.txt
