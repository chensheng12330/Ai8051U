# Keil uVision project ceshi.uvproj, settings and files
target QD-TFT (MCS-251)
  device: STC8051U-32Bit Series STC
  cpu: IRAM(0-0x7FF) XRAM(0x10000-0x17FFF) IROM(0xFF0000-0xFFFFFF) CLOCK(35000000)
  output: ceshi +hex
  link misc: REMOVEUNUSED
  group USER
    ../GUI/: gui.c
    ../USER/: main.c test.c 功能说明.txt ISR.asm
  group SYSTEM
    ../sys/: sys.c
  group HARDWARE
    ../LCD/: LCD.c
    ../touch/: touch.c
