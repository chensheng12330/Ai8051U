# Keil uVision project SPI.uvproj, settings and files
target Target 1 (MCS-251)
  device: STC8051U-32Bit Series STC
  cpu: IRAM(0-0x7FF) XRAM(0x10000-0x17FFF) IROM(0xFF0000-0xFFFFFF) CLOCK(35000000)
  output: SPI +hex
  group Source Group 1
    ./: WS2812B-SPI-DMA-32灯环-跑马灯.c
