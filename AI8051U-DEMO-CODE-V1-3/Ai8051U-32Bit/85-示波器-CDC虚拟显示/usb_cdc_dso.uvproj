# Keil uVision project usb_cdc_dso.uvproj, settings and files
target dso (MCS-251)
  device: AI8051U-32Bit Series AI
  cpu: IRAM(0-0x7FF) XRAM(0x10000-0x17FFF) IROM(0xFF0000-0xFFFFFF) CLOCK(35000000)
  output: usb_cdc_dso +hex
  link misc: REMOVEUNUSED
  group main
    ./src/: uart.c OSCOPE-V2-8bit-CDC.c EEPROM.c
  group usb
    ./src/usb/: usb.c usb_desc.c usb_req_class.c usb_req_std.c usb_req_vendor.c util.c
