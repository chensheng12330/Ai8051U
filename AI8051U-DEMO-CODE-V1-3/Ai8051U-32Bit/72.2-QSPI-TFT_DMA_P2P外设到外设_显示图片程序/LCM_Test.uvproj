# Keil uVision project LCM_Test.uvproj, settings and files
target Target 1 (MCS-251)
  device: STC8051U-32Bit Series STC
  cpu: IRAM(0-0x7FF) XRAM(0x10000-0x17FFF) IROM(0xFF0000-0xFFFFFF) CLOCK(35000000)
  output: LCM_Test +hex
  link misc: REMOVEUNUSED
  group Source Group 1
    ./Sources/: main.c SPI_Flash.c ISR.asm uart.c lcm.c iap_eeprom.c qspi.c w25qxx.c
    ./: 功能说明.txt
