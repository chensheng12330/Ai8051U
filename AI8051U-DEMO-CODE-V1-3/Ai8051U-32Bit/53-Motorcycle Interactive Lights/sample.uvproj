# Keil uVision project sample.uvproj, settings and files
target Target 1 (MCS-251)
  device: STC8051U-32Bit Series STC
  cpu: IRAM(0-0x7FF) XRAM(0x10000-0x17FFF) IROM(0xFF0000-0xFFFFFF) CLOCK(35000000)
  output: sample +hex
  link misc: REMOVEUNUSED
  group usr
    ./Sources/src/: main.c Task.c System_init.c
  group isr
    ./Sources/isr/: Timer_Isr.c
  group app
    ./Sources/src/: adc.c app.c app_adcKey.c app_display.c app_intKey.c motorcycle_light_system.c
  group tool
    ./TaskMonitor/: TaskMonitor.c
    ../COMM/: usb_hid_32.LIB
