# Keil uVision project sample.uvproj, settings and files
target Sample (MCS-251)
  device: AI8051U-32Bit Series AI
  cpu: IRAM(0-0x7FF) XRAM(0x10000-0x17FFF) IROM(0xFF0000-0xFFFFFF) CLOCK(35000000)
  output: sample +hex
  group Source
    ./: main.c ISR.ASM 功能说明.txt
