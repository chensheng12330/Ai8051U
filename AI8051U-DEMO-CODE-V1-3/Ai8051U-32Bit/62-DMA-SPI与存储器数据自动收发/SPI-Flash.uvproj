# Keil uVision project SPI-Flash.uvproj, settings and files
target SPI-PM25LV040 (MCS-251)
  device: STC8051U-32Bit Series STC
  cpu: IRAM(0-0x7FF) XRAM(0x10000-0x17FFF) IROM(0xFF0000-0xFFFFFF) CLOCK(35000000)
  output: SPI-Flash +hex
  group Source
    ./: ISR.asm SPI-Flash.c 功能说明.txt
