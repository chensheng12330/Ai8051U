# Keil uVision project QSPI_TFT_Demo.uvproj, settings and files
target Target 1 (MCS-251)
  device: AI8051U-32Bit Series AI
  cpu: IRAM(0-0x7FF) XRAM(0x10000-0x17FFF) IROM(0xFF0000-0xFFFFFF) CLOCK(35000000)
  output: QSPI_TFT_Demo +hex
  link misc: REMOVEUNUSED
  group Source Group 1
    ./Sources/: qspi.c w25qxx.c lcm.c tft.c usbcdc.c timer.c main.c usb_cdc_32g.LIB
    ./: 功能说明.txt
