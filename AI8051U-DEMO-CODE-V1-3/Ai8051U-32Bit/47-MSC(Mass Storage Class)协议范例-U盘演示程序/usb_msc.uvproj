# Keil uVision project usb_msc.uvproj, settings and files
target Target 1 (MCS-251)
  device: STC8051U-32Bit Series STC
  cpu: IRAM(0-0x7FF) XRAM(0x10000-0x17FFF) IROM(0xFF0000-0xFFFFFF) CLOCK(35000000)
  output: usb_msc +hex
  group Source Group 1
    ./src/: main.c usb.c usb_desc.c usb_req_class.c usb_req_std.c usb_req_vendor.c util.c scsi.c memory.c
    ./: 功能说明.txt
