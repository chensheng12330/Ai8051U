# Keil uVision project usart_spi_dma-demo.uvproj, settings and files
target demo (MCS-251)
  device: STC8051U-32Bit Series STC
  cpu: IRAM(0-0x7FF) XRAM(0x10000-0x17FFF) IROM(0xFF0000-0xFFFFFF) CLOCK(35000000)
  output: usart_spi_dma-demo +hex
  link misc: REMOVEUNUSED
  group main
    ./src/: main.c
    ../COMM/: usb_cdc_32.LIB
    ./: 功能说明.txt
