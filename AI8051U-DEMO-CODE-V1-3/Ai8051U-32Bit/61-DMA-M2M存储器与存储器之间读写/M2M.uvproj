# Keil uVision project M2M.uvproj, settings and files
target UART1 (MCS-251)
  device: STC8051U-32Bit Series STC
  cpu: IRAM(0-0x7FF) XRAM(0x10000-0x17FFF) IROM(0xFF0000-0xFFFFFF) CLOCK(35000000)
  output: M2M +hex
  group Source
    ./: isr.asm M2M.c 功能说明.txt
