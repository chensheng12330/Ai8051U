# Keil uVision project sample.uvproj, settings and files
target Sample (MCS-251)
  device: STC8051U-32Bit Series STC
  cpu: IRAM(0-0x7FF) XRAM(0x10000-0x17FFF) IROM(0xFF0000-0xFFFFFF) CLOCK(35000000)
  output: sample +hex
  group Source
    ./: main-LCM-DMA-接R-2R输出波形.c
