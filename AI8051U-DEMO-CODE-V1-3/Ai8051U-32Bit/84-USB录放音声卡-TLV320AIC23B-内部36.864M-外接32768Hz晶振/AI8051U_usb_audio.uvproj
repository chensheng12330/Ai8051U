# Keil uVision project AI8051U_usb_audio.uvproj, settings and files
target usb_audio_i2s_48k_16b_2ch (MCS-251)
  device: AI8051U-32Bit Series AI
  cpu: IRAM(0-0x7FF) XRAM(0x10000-0x17FFF) IROM(0xFF0000-0xFFFFFF) CLOCK(35000000)
  output: usb_audio_i2s_48k_16b_2ch +hex
  link misc: REMOVEUNUSED
  group Source Group 1
    ./src/: usb.c usb_desc.c usb_req_class.c usb_req_std.c usb_req_vendor.c util.c i2s.c clock.c TLV320AIC23.c STC32_MDU32_LARGE_V1.1.LIB main.c
