# Keil uVision project Comparator.uvproj, settings and files
target Comparator (MCS-251)
  device: STC8051U-32Bit Series STC
  cpu: IRAM(0-0x7FF) XRAM(0x10000-0x17FFF) IROM(0xFF0000-0xFFFFFF) CLOCK(35000000)
  output: Comparator +hex
  group Source
    ./: Comparator.asm 功能说明.txt
