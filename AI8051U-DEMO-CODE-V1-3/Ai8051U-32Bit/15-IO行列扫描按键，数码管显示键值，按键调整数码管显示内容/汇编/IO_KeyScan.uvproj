# Keil uVision project IO_KeyScan.uvproj, settings and files
target IO_KeyScan (MCS-251)
  device: STC8051U-32Bit Series STC
  cpu: IRAM(0-0x7FF) XRAM(0x10000-0x17FFF) IROM(0xFF0000-0xFFFFFF) CLOCK(35000000)
  output: IO_KeyScan +hex
  group Source
    ./: IO_KeyScan.asm 功能说明.txt
