# Keil uVision project test.uvproj, settings and files
target Target 1 (MCS-251)
  device: STC8051U-32Bit Series STC
  cpu: IRAM(0-0x7FF) XRAM(0x10000-0x17FFF) IROM(0xFF0000-0xFFFFFF) CLOCK(35000000)
  output: test +hex
  group Source Group 1
    ./: TFT240x240-ST7789-SPI-DMA-V10.c
