# Keil uVision project LCD1602.uvproj, settings and files
target LCD128x64 (MCS-251)
  device: STC8051U-32Bit Series STC
  cpu: IRAM(0-0x7FF) XRAM(0x10000-0x17FFF) IROM(0xFF0000-0xFFFFFF) CLOCK(35000000)
  output: LCD1602 +hex
  group Source
    ./: LCD1602.c 功能说明.txt
