# Keil uVision project voltage.uvproj, settings and files
target voltage (MCS-251)
  device: STC8051U-32Bit Series STC
  cpu: IRAM(0-0x7FF) XRAM(0x10000-0x17FFF) IROM(0xFF0000-0xFFFFFF) CLOCK(35000000)
  output: voltage +hex
  group Source
    ./: voltage.asm 功能说明.txt
